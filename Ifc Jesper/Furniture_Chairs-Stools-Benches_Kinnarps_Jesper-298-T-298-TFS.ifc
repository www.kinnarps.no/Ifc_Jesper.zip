Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Furniture_Chairs-Stools-Benches_Kinnarps_Jesper-298-T-298-TFS.ifc
Time: 2021-10-11T15:31:37
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: Jesper 298 T, 298 TFS
ePset_BIMobjectScript - Foot rest: On; Variant: 298 TFS - Birch; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Jesper 298 T, 298 TFS; SKU (BO_prodsku): jesper-298t; ManufacturName (BO_Manufac): Kinnarps; BrandUrl (BO_brandurl): http://www.kinnarps.com/; ProductFamily (BO_prodfam): Jesper; ProductGroup (BO_prodgroup): Jesper; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 0; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/kinnarps/product/jesper-298t; ProductDataUrl (BO_prodaturl): bimobject.com/kinnarps/product/jesper-298t; ProductUrl (BO_producturl): https://www.kinnarps.com/products/seating/education-chairs/jesper/; BimObjectMainCategory (BO_bomaincat): Furniture; BimObjectMainCategoryCode (BO_bomaincat_code): furniture; BimObjectCategory (BO_bocat): Chairs, Stools & Benches; BimObjectCategoryCode (BO_bocat_code): chairs-stools-benches; IfcClassification (BO_ifcclas): Furniture; OmniClassCode (BO_omniclass_code): 23-21 25 11 13; OmniClassDescription (BO_omniclass_name): Classroom Furniture; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
